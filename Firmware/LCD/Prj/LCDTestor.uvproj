# Keil uVision project LCDTestor.uvproj, settings and files
target LCDTestor (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: LCDTestor
  c flags: Optim=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\LCD;..\Libraries\CMSIS\Core\CM3;..\CortexM3;..\Prj;..\User;..\BSP
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ../User/: main.c
  group Lib
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_it.c
    ../Libraries/CMSIS/Core/CM3/: core_cm3.c system_stm32f10x.c
  group Bsp
    ../BSP/: bsp.c Lights.c
    ../User/: LCD_HSD080.c
  group RVMDK
    ../Libraries/CMSIS/Core/CM3/startup/arm/: startup_stm32f10x_hd.s
