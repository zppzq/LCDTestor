# Keil uVision project SJ-VSA.uvproj, settings and files
target Z32R (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: uCOSii
  c flags: Optim=1 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\Libraries\CMSIS\Core\CM3;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\User;..\SDK\BSP;..\CortexM3;..\uCOS;..\ColBus;..\SDK
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ../User/: main.c stm32f10x_it.c stm32f10x_conf.h stm32f10x_it.h
    ./: record.txt
  group BSP
    ../SDK/BSP/: bsp.c spi.c Serial.c Lights.c
    ../User/: LCD_HSD080.c
  group CortexM3
    ../CortexM3/: cpu_a.asm os_cpu_a.asm os_cpu_c.c
  group uCOS
    ../uCOS/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group StdPeriph_Driver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_usart.c misc.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_tim.c stm32f10x_bkp.c stm32f10x_rtc.c stm32f10x_pwr.c
  group CMSIS
    ../Libraries/CMSIS/Core/CM3/: core_cm3.c system_stm32f10x.c
  group RVMDK
    ../Libraries/CMSIS/Core/CM3/startup/arm/: startup_stm32f10x_hd.s
